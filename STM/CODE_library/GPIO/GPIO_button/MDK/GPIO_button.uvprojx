# Keil uVision project GPIO_button.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GPIO_button
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\LIB\Libraries\CMSIS\ST\STM32F0xx\Include;..\LIB\Utilities\STM32F0-Discovery;..\LIB\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\LIB\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group library
    ../LIB/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_flash.c
  group user
    ../USER/: main.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
